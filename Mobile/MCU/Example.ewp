# IAR project Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; IAR_ARM_CM3; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: Libraries\DisplayDriver\; Libraries\CMSIS\CM3\CoreSupport\; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\STM32F10x_StdPeriph_Driver\inc\; FreeRTOS\Include\; FreeRTOS\Portable\IAR\ARM_CM3\; Game\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Example.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    Control/: Control.c
    Libraries/DisplayDriver/: DisplayDriver.c
    Game/: SndDriver.c
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    FreeRTOS/portable/MemMang/: heap_4.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group Game
    Game/: Animations.c Chars.c ChrScripts.c FooterTiles.c Game.c Graphics.c Locations.c LocScripts.c Player.c StandbyScript.c
  group StdPeriphDrivers
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
